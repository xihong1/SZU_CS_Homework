.ORIG X3000;
LD R6 STACK;
LD R1 ENTRY;
LD R2 RUPT;
STR R2 R1 #0;
LD R3 IE;
STI R3 KBSR;
;
START AND R4 R4 #0;
ADD R4 R4 #6;
PRINT1 LEA R0,ICS1;
PUTS;
JSR DELAY;
ADD R4 R4 #-1;
BRP PRINT1;
LD R0 NEXTLINE;
OUT;
JSR DELAY;
AND R4 R4 #0;
ADD R4 R4 #5;
PRINT2 LEA R0 ICS2;
PUTS;
JSR DELAY;
ADD R4 R4 #-1;
BRP PRINT2;
LD R0 NEXTLINE;
OUT;
JSR DELAY;
BRNZP START;
HALT
;
DELAY ST R1,SAVER1;
LD R1,COUNT;
REP ADD R1,R1,#-1;
BRP REP;
LD R1,SAVER1
RET;
;
STACK .FILL X4000;
RUPT .FILL X2000;
ENTRY .FILL X0180;
IE .FILL X4000;
COUNT .FILL #2500;
SAVER1 .BLKW 1;
ICS1 .STRINGZ "ICS   ";
ICS2 .STRINGZ "   ICS";
KBSR .FILL XFE00;
NEXTLINE .FILL 10;
.END