.ORIG x3000;
LD R0 DATE;读取数据
LD R1 SHUJU;保存数据地址
ADD R2 R2 #15;控制循环
X BRn WC;
LDR R3 R0 #0;
STR R3 R1 #0;
ADD R0 R0 #1
ADD R1 R1 #1
ADD R2 R2 #-1
BRNZP X
WC AND R1 R1 #0;
LD R1 SHUJU;
AND R2 R2 #0
ADD R2 R2 #15;外层循环，后面的是I=R2
WAIXUNHUAN AND R3 R3 #0;
ADD R3 R2 #-1;内层循环，前面的是j=R3
NEIXUNHUAN AND R4 R4 #0
AND R5 R5 #0
ADD R4 R1 R2;最后一位开始比较，如果最后一位小则不交换，否则交换
ADD R5 R1 R3;R5=&A[J],R4=&A[I]
LDR R6 R4 #0;R6=*R4,R7=*r5
LDR R7 R5 #0
NOT R0 R6
ADD R0 R0 #1
ADD R0 R0 R7
BRzp NEXT
STR R6 R5 #0
STR R7 R4 #0
NEXT ADD R3 R3 #-1
BRzp NEIXUNHUAN
ADD R2 R2 #-1
BRzp WAIXUNHUAN
AND R0 R0 #0
AND R1 R1 #0
AND R3 R3 #0
AND R2 R2 #0
AND R4 R4 #0
ADD R4 R4 #4;R4控制循环
AND R7 R7 #0;r7记录a等级个数
AND R6 R6 #0;r6记录b等级
LD R0 APERSON;R0=-85;
LD R1 BPERSON;r1=-75
LD R2 SHUJU;读入数据地址
XUNHUAN LDR R3 R2 #0;R3为数据
ADD R5 R3 R1;
BRn NEXTA;
ADD R6 R6 #1;
ADD R5 R3 R0;
BRn NEXTA;
ADD R6 R6 #-1;
ADD R7 R7 #1;
NEXTA ADD R2 R2 #1;
ADD R4 R4 #-1;
BRp XUNHUAN
LD R0 RENSHU;
STR R7 R0 #0;
ADD R0 R0 #1;
ADD R4 R4 #4;R4控制循环
XUNHUANT LDR R3 R2 #0;R3为数据
ADD R5 R3 R1;
BRn NEXTT
ADD R6 R6 #1;
NEXTT ADD R2 R2 #1;
ADD R4 R4 #-1;
BRp XUNHUANT
STR R6 R0 #0;
HALT
DATE .FILL X3200
SHUJU .FILL X4000
RENSHU .FILL X4100
APERSON .FILL XFFAB
BPERSON .FILL XFFB5
.END