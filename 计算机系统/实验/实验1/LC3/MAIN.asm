.ORIG X2000;
ADD R6 R6 #-1;
STR R0 R6 #0;
ADD R6 R6 #-1;
STR R1 R6 #0;
ADD R6 R6 #-1;
STR R2 R6 #0;
ADD R6 R6 #-1;
STR R3 R6 #0;
;
ISPUT LDI R1,KBSR;
BRZP ISPUT;
LDI R0 KBDR;
;;ST R0,VALUER0;
LD R2 NNEXTLINE;
ADD R2 R2 R0;
BRZ ISEND;
AND R3 R3 #0;
ADD R3 R3 #10;
;
ISOUT LDI R1,DSR;
BRZP ISOUT;
STI R0,DDR;
ADD R3 R3 #-1;
BRP ISOUT;
BRNZP ISPUT;
;
ISEND LDR R3 R6 #0;
ADD R6 R6 #1;
LDR R2 R6 #0;
ADD R6 R6 #1;
LDR R1 R6 #0;
ADD R6 R6 #1;
LDR R0 R6 #0;
ADD R6 R6 #1;
RTI;
;
VALUER0 .FILL 0;
KBSR .FILL XFE00;
KBDR .FILL XFE02;
NNEXTLINE .FILL XFFF6;
DSR .FILL XFE04;
DDR .FILL XFE06;
.END