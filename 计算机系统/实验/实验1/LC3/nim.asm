.ORIG	x3000
LD R1 VR1;
LD R2 VR2;
LD R3 VR3;
JSR SHOW;
NEXTTURN JSR P1IN;
LD R0 NEXTLINE;
TRAP X21;
JSR ISEND;
ADD R4 R4 #0;
BRNP TOP2;
LEA R0 P1WIN;
TRAP X22;
BRNZP EXITALL;
TOP2 JSR P2IN;
LD R0 NEXTLINE;
TRAP X21;
JSR ISEND;
ADD R4 R4 #0;
BRNP NEXTTURN;
LEA R0 P2WIN;
TRAP X22;
BRNZP EXITALL;
EXITALL HALT
;
P1IN ST R7 R7V;
P1RETURN LEA R0 P1SHOW;
TRAP X22;
TRAP X20;
TRAP X21;
ADD R4 R0 #0;r4是abc行数，目前没有输入数字
TRAP X20;
TRAP X21;
ADD R5 R0 #0;R5是输入的数字
LD R0 NEXTLINE;
TRAP X21;
LD R0 VALUE0;
ADD R5 R5 R0;减去ASCII'0'
BRN P1FILLIN;
NOT R5 R5;
ADD R5 R5 #1;取反加一
JSR ISABC;
AND R4 R4 #0;
ADD R6 R6 #-1;
BRZ INALINE;
ADD R6 R6 #-1;
BRZ INBLINE;
ADD R6 R6 #-1;
BRZ INCLINE;
P1FILLIN LEA R0 FAILIN;
TRAP X22;
LD R0 NEXTLINE;
TRAP X21
BRNZP P1RETURN;
INALINE ADD R4 R1 R5;
BRN P1FILLIN;
ADD R1 R1 R5;
BRZP P1EXIT;
INBLINE ADD R4 R2 R5;
BRN P1FILLIN;
ADD R2 R2 R5;
BRZP P1EXIT;
INCLINE ADD R4 R3 R5;
BRN P1FILLIN;
ADD R3 R3 R5;
BRZP P1EXIT;
P1EXIT JSR SHOW;
LD R7 R7V;
RET;
;
P2IN ST R7 R7V;
P2RETURN LEA R0 P2SHOW;
TRAP X22;
TRAP X20;
TRAP X21;
ADD R4 R0 #0;r4是abc行数，目前没有输入数字
TRAP X20;
TRAP X21;
ADD R5 R0 #0;R5是输入的数字
LD R0 NEXTLINE;
TRAP X21;
LD R0 VALUE0;
ADD R5 R5 R0;减去ASCII'0'
BRN P1FILLIN;
NOT R5 R5;
ADD R5 R5 #1;取反加一
JSR ISABC;
AND R4 R4 #0;
ADD R6 R6 #-1;
BRZ ISSALINE;
ADD R6 R6 #-1;
BRZ ISSBLINE;
ADD R6 R6 #-1;
BRZ ISSCLINE;
P2FILLIN LEA R0 FAILIN;
TRAP X22;
LD R0 NEXTLINE;
TRAP X21;
BRNZP P2RETURN;
ISSALINE ADD R4 R1 R5;
BRN P2FILLIN;
ADD R1 R1 R5;
BRZP P2EXIT;
ISSBLINE ADD R4 R2 R5;
BRN P2FILLIN;
ADD R2 R2 R5;
BRZP P2EXIT;
ISSCLINE ADD R4 R3 R5;
BRN P2FILLIN;
ADD R3 R3 R5;
BRZP P2EXIT;
P2EXIT JSR SHOW;
LD R7 R7V;
RET;
; 
FAILIN .STRINGZ "Invalid move. Try again.";
VALUE0 .FILL #-48;
R7V .FILL 0;
;
ISABC AND R6 R6 #0;
ST R5 STVR5;
LD R5 ALINE;
ADD R0 R4 #0;
ADD R4 R0 R5;
BRZ ISA;
LD R5 BLINE;
ADD R4 R0 R5;
BRZ ISB;
LD R5 CLINE;
ADD R4 R0 R5;
BRZ ISC;
BRNZP EXITIS;
ISA ADD R6 R6 #1;
BRNZP EXITIS;
ISB ADD R6 R6 #2;
BRNZP EXITIS;
ISC ADD R6 R6 #3;
EXITIS LD R5 STVR5;
RET;
;
ISEND ADD R4 R1,R2;比较是否胜利
ADD R4 R4,R3;出来判断R4是不是0
RET
;
SHOW ST R1,STVR1;
ST R2,STVR2;
ST R3,STVR3;
ST R7,STVR7;
LEA R0 SHOWROWA
TRAP X22;
SHOWA ADD R1 R1 #-1;
BRn NSHOWB;
LD R0 SHOWO;
TRAP X21;
BRnzp SHOWA;
;
NSHOWB LD R0 NEXTLINE;
TRAP X21;
LEA R0 SHOWROWB;
TRAP X22;
SHOWB ADD R2 R2 #-1;
BRn NSHOWC;
LD R0 SHOWO;
TRAP X21;
BRnzp SHOWB;
;
NSHOWC LD R0 NEXTLINE;
TRAP X21;
LEA R0 SHOWROWC;
TRAP X22;
SHOWC ADD R3 R3 #-1;
BRn SHOWEND;
LD R0 SHOWO;
TRAP X21;
BRnzp SHOWC;
SHOWEND LD R7,STVR7;
LD R1,STVR1;
LD R2,STVR2;
LD R3,STVR3;
RET
;
VR1 .FILL #3;
VR2 .FILL #5;
VR3 .FILL #8;
SHOWROWA .STRINGZ "ROW A: ";
SHOWROWB .STRINGZ "ROW B: ";
SHOWROWC .STRINGZ "ROW C: ";
SHOWO .STRINGZ "o";
NEXTLINE .FILL X000A;
STVR1 .FILL 0;
STVR2 .FILL 0;
STVR3 .FILL 0;
STVR5 .FILL 0;
STVR7 .FILL 0;
P1WIN .STRINGZ "Player 1 Wins.";
P2WIN .STRINGZ "Player 2 Wins.";
P1SHOW .STRINGZ "Player 1,choose a row and number of rocks: ";
P2SHOW .STRINGZ "Player 2,choose a row and number of rocks: ";
ALINE .FILL #-65;
BLINE .FILL #-66;
CLINE .FILL #-67;
.END;
